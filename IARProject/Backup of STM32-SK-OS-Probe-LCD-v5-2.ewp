# IAR project Backup of STM32-SK-OS-Probe-LCD-v5-2.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401xE ST STM32F401xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F401xE
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\BSP; ..\..\..\..\..\CPU\ST\STM32\inc; ..\..\..\..\..\uC-CPU; ..\..\..\..\..\uC-CPU\ARM-Cortex-M3\IAR; ..\..\..\..\..\uC-LCD\Source; ..\..\..\..\..\uC-LIB; ..\..\..\..\..\uCOS-II\Ports\ARM-Cortex-M3\Generic\IAR; ..\..\..\..\..\uCOS-II\Source; ..\..\..\..\..\uC-Probe\Target\Communication\Generic\RS-232\Source; ..\..\..\..\..\uC-Probe\Target\Communication\Generic\RS-232\Ports\ST\STM32; ..\..\..\..\..\uC-Probe\Target\Communication\Generic\Source; ..\..\..\..\..\uC-Probe\Target\Plugins\uCOS-II; E:\emb\105230341Micrium\Micrium\Software\CPU\ST\STM32\m4inc; E:\emb\105230341Micrium\Micrium\Software\CPU\ST\STM32\m4inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32-SK-OS-Probe-LCD-v5-2.srec
  ILINK.IlinkOutputFile: STM32-SK-OS-Probe-LCD-v5.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f401xE.icf
  ILINK.IlinkAdditionalLibs: E:\项目\IAR项目文件\STM32_NUCLEO\stm32cubef4\STM32Cube_FW_F4_V1.3.0\Projects\STM32F401RE-Nucleo\Templates\EWARM\STM32F4xx-Nucleo\Exe\Project.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APP/General
    ./: app.c app_cfg.h includes.h os_cfg.h probe_com_cfg.h
    ../BSP/: startup_stm32f401xe.s
  group APP/ST
    ./: stm32f10x_conf.h
  group BSP/General
    ../BSP/: STM32_FLASH.icf
  group uC/CPU
    ../../../../../uC-CPU/ARM-Cortex-M3/IAR/: cpu.h cpu_a.asm cpu_c.c
    ../../../../../uC-CPU/: cpu_def.h
    ../../../../../CPU/ST/STM32/m4inc/: stm32f4xx_hal_def.h
  group uC/LIB
    ../../../../../uC-LIB/: lib_def.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC/LIB/Ports
    ../../../../../uC-LIB/Ports/ARM-Cortex-M3/IAR/: lib_mem_a.asm
  group uC/OS-II/Port
    ../../../../../uCOS-II/Ports/ARM-Cortex-M3/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uC/OS-II/Source
    ../../../../../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
