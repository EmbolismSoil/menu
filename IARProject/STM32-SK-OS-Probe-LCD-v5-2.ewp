# IAR project STM32-SK-OS-Probe-LCD-v5-2.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401xE ST STM32F401xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F401xE; USE_STM32F4XX_NUCLEO
  ICCARM.CCIncludePath2: ..\uCOS-II\Source; ..\IARProject; ..\IAR_CPU; ..\BSP; ..\IARProject; ..\uC-CPU\ARM-Cortex-M3\IAR; ..\uC-CPU; ..\uC-LIB; ..\uC-Probe\Target\Communication\Generic\Source; ..\uC-Probe\Target\Plugins\uCOS-II; ..\uC-Probe\Target\Communication\Generic\RS-232\Source; ..\uC-Probe\Target\Communication\Generic\RS-232\Source; ..\uC-Probe\Target\Communication\Generic\RS-232\Ports\ST\STM32; ..\CPU\ST\STM32\m4inc; ..\UserCode; ..\UserCode\userdriver
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32-SK-OS-Probe-LCD-v5-2.srec
  ILINK.IlinkOutputFile: STM32-SK-OS-Probe-LCD-v5-2.out
  ILINK.IlinkIcfFile: E:\电赛\训练\软件\userProj\BSP\stm32f401xe_flash.icf
  ILINK.IlinkAdditionalLibs: ..\StaticLib\stm32f401DriverLib.a; ..\StaticLib\ucosii.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APP
    ../UserCode/: app.c clock.c fifo.c menu.c stm32f4xx_it.c
    ../UserCode/userdriver/: LCD12864P.c
